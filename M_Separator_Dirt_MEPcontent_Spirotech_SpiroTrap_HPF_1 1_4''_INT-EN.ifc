Properties of the parts of a building model (IFC4)

# File
Description: ViewDefinition [CoordinationView_V2.0], ExchangeRequirement []
File name: Project Number
Time: 2026-02-10T14:32:07+02:00
Written by: ODA SDAI 22.12
Made in: 23.0.11.19 - Exporter 23.0.11.19 - Default UI

# IfcProject, Project Number
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 23, 13, 199999; RefLongitude: -71, -14, -31, -199999; RefElevation: 0 mm
Pset_SiteCommon - Reference: Project Information
Other - Category: Project Information; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status; S4R_Use_nominal_diameter: yes

# IfcBuilding
Pset_BuildingCommon - Reference: Project Information; NumberOfStoreys: 1
Pset_BuildingElementProxyCommon - Reference: Project Information; IsExternal: no
Pset_BuildingStoreyCommon - Reference: Project Information; sets with these values: 2
Other - Category: Project Information; S4R_Use_nominal_diameter: yes; Client Name: Client Name; Project Address: Enter address here; Project Issue Date: Project Issue Date; Project Name: Project Name; Project Number: Project Number; Project Status: Project Status

# IfcBuildingStorey: Level:Floor Level, F00
LongName: F00; Elevation: 0 mm
Pset_BuildingStoreyCommon - Reference: Floor Level
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: F00; Structural: no
Other - Category: Levels; Family: Level; Family and Type: Level: Floor Level; Type: Floor Level; Type Id: 305
Constraints(Type) - Elevation Base: Project Base Point
Graphics(Type) - Color: 0; Line Pattern: Solid; Line Weight: 1; Symbol: GE_tag_level_floor_MEPcontent : standard; Symbol at End 1 Default: yes; Symbol at End 2 Default: yes
Identity Data(Type) - Type Name: Floor Level
Other(Type) - Category: Levels; Family Name: Level

# IfcDistributionPort (2)
Description: Flow; PredefinedType: PIPE
Name | FlowDirection
Port_1310198 | SINK
Port_1310198 | SOURCE

# IfcValve: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HPF_INT-EN:1 1/4'', M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HPF_INT-EN:1 1/4'':1310198
In: F00
Type - Material: Color RGB 055-055-055, Color RGB 255-255-255, Color RGB 168-128-048
Type - Constraints - Default Elevation: 0 mm
Type - Dimensions - Connection Diameter: 31.75 mm; Depth: 110 mm; Height: 206 mm; Use Nominal Diameter: yes; Width: 196 mm
Type - Identity Data - Article Description: Brass heat pump filter with magnet and universal connection; Article Type: 1 1/4''; Base Family Version: 26.02; Content Supplier URL: www.MEPcontent.com; Copyright: © Trimble Europe BV; Custom: no; Description: Brass heat pump filter with magnet and universal connection; EMCS Version: 5.0; ETIM Article Class: EC010260; Family Version: 26.02; GLN: 8717811000007; GTIN: 8717811067437; Manufacturer: Spirotech; Manufacturer Art. No.: UE125XJF; Manufacturer URL: https://www.spirotech.com/products/spirotrap/; MEPcontent Class: SEPARATOR_DIRT; Model: 1 1/4''; OmniClass Number: 23.70.50.14.31; OmniClass Title: Liquid Waste Separators; Product Line: SpiroTrap; Revit Version: 2023; Type Name: 1 1/4''; URL: https://mep.trimble.com; Watermarked By: https://mep.trimble.com
Type - Materials and Finishes - Black: Color RGB 055-055-055; Brass Yellow: Color RGB 168-128-048; Insulation Material: Color RGB 202-209-238; White: Color RGB 235-235-235
Type - Mechanical - Kvs: 12; Max Flow: 0.000347222 m3/s; Maximum Operating Pressure: 600000 Pa; Maximum Temperature: 75 C; Maximum Velocity: 1 m/s; Volume: 0.00089 m3; Weight: 4.4 kg
Type - Other - Category: Pipe Accessories; Connection Nominal Diameter: 31.75 mm; Connection Outer Diameter: 42.4 mm; Connection Radius: 15.875 mm; Connector Length: 128 mm; Connector Length Model Line: 84 mm; Family Name: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HPF_INT-EN; Inch Dimensions Visibility: yes; Insulation Hole Radius: 33 mm; MM Dimensions Visibility: no; Outer Diameter: 42.4 mm; Radius: 21.2 mm; Radius 2: 25.4 mm; Radius Void: 21.4 mm; Tube Outside Radius: 21.2 mm; Tube Radius: 21.4 mm; Tube Radius 2: 23.4 mm; Washer Length: 22 mm
Type - Pset_ManufacturerTypeInformation - Manufacturer: Spirotech
Pset_EnvironmentalImpactIndicators - Reference: 1 1/4''; sets with these values: 2
Constraints - Actual Offset: 10 mm; Elevation from Level: 0 mm; Negative Offset: 10 mm
Dimensions - Area: 0.206996 m2; Maximum Size: 31.75 mm; Minimum Size: 31.75 mm; Volume: 0.00179615 m3
Graphics - Annotation Offset RL: 0 mm
Identity Data - Mark: 11
Insulation - Insulation Thickness: 0 mm
Mechanical - System Classification: Undefined
Mechanical - Flow - Flow In: 0 m3/s; Flow Out: 0 m3/s; Pressure Drop: 0 Pa
Other - Bottom Clearance Safe: 200 mm; Family: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HPF_INT-EN; Family and Type: M_Separator_Dirt_MEPcontent_Spirotech_SpiroTrap_HPF_INT-EN: 1 1/4''; Top Clearance Safe: 200 mm; Total Length: 110 mm; Total Width: 196 mm; Type: 1 1/4''; Type Id: 1310178
Phasing - Phase Created: 3. New Construction
Visibility - Bottom Clearance: 200 mm; Insulation: no; Service Space: no; Top Clearance: 200 mm
